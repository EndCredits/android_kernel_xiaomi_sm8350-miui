## drivers/mihw/Kconfig
```kconfig
config MILLET
	bool "frozen framework"
	default y
	depends on MIHW
	---help---
	  Mi frozen function
```
